# Keil uVision project STM32F051R8Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F051R8Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\STM32F0xx_StdPeriph_Driver;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source;.\User\Include;.\User\Source;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./User/Source/: main.c lcd_lib.c game_2048.c lcd_main_menu.c snake.c game_tetris.c speaker.c tim_but_led_pwm.c infrared_receiver.c
  group SPL
    ./STM32F0xx_StdPeriph_Driver/: stm32f0xx_conf.h
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_comp.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group StartUp
    ./: startup_stm32f051x8.s
